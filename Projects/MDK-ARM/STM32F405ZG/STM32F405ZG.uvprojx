# Keil uVision project STM32F405ZG.uvprojx, settings and files
target Debug (6210000::V6.21::ARMCLANG)
  device: STM32F405ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Debug
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=9 wLevel=3
  c define: STM32F405xx,Enable_EventRecorder,OS_EVR_INIT=1
  c include: ..\..\App;..\..\Core;..\..\Core\CMSIS-RTX;..\..\Core\CMSIS-View;..\..\Core\Device\STM32F405ZGTx;..\..\..\Drivers\BSP;..\..\..\Drivers\CMSIS_6\CMSIS\Core\Include;..\..\..\Drivers\CMSIS_6\CMSIS\RTOS2\Include;..\..\..\Drivers\CMSIS-DSP\Include;..\..\..\Drivers\CMSIS-DSP\PrivateInclude;..\..\..\Drivers\CMSIS-RTX\Include;..\..\..\Drivers\CMSIS-Device\ST\STM32F4xx\Include;..\..\..\Drivers\CMSIS-View\EventRecorder\Include;..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\Utilities
  asm include: ..\..\App;..\..\Core;..\..\Core\CMSIS-RTX;..\..\..\Drivers\CMSIS-RTX\Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\..\Core\Device\STM32F405ZGTx\stm32f405xx.sct
  group Drivers/BSP
    ../../../Drivers/BSP/: bsp.c
  group Drivers/CMSIS-DSP
    ../../../Drivers/CMSIS-DSP/Source/BasicMathFunctions/: BasicMathFunctions.c BasicMathFunctionsF16.c
    ../../../Drivers/CMSIS-DSP/Source/BayesFunctions/: BayesFunctions.c BayesFunctionsF16.c
    ../../../Drivers/CMSIS-DSP/Source/CommonTables/: CommonTables.c CommonTablesF16.c
    ../../../Drivers/CMSIS-DSP/Source/ComplexMathFunctions/: ComplexMathFunctions.c ComplexMathFunctionsF16.c
    ../../../Drivers/CMSIS-DSP/Source/ControllerFunctions/: ControllerFunctions.c
    ../../../Drivers/CMSIS-DSP/Source/DistanceFunctions/: DistanceFunctions.c DistanceFunctionsF16.c
    ../../../Drivers/CMSIS-DSP/Source/FastMathFunctions/: FastMathFunctions.c FastMathFunctionsF16.c
    ../../../Drivers/CMSIS-DSP/Source/FilteringFunctions/: FilteringFunctions.c FilteringFunctionsF16.c
    ../../../Drivers/CMSIS-DSP/Source/InterpolationFunctions/: InterpolationFunctions.c InterpolationFunctionsF16.c
    ../../../Drivers/CMSIS-DSP/Source/MatrixFunctions/: MatrixFunctions.c MatrixFunctionsF16.c
    ../../../Drivers/CMSIS-DSP/Source/QuaternionMathFunctions/: QuaternionMathFunctions.c
    ../../../Drivers/CMSIS-DSP/Source/StatisticsFunctions/: StatisticsFunctions.c StatisticsFunctionsF16.c
    ../../../Drivers/CMSIS-DSP/Source/SupportFunctions/: SupportFunctions.c SupportFunctionsF16.c
    ../../../Drivers/CMSIS-DSP/Source/SVMFunctions/: SVMFunctions.c SVMFunctionsF16.c
    ../../../Drivers/CMSIS-DSP/Source/TransformFunctions/: TransformFunctions.c TransformFunctionsF16.c
    ../../../Drivers/CMSIS-DSP/Source/WindowFunctions/: WindowFunctions.c
  group Drivers/CMSIS-RTX
    ../../../Drivers/CMSIS-RTX/Source/GCC/: irq_armv7m.S
    ../../../Drivers/CMSIS-RTX/Source/: rtx_delay.c rtx_evflags.c rtx_evr.c rtx_kernel.c rtx_lib.c rtx_memory.c rtx_mempool.c rtx_msgqueue.c rtx_mutex.c rtx_semaphore.c rtx_system.c rtx_thread.c rtx_timer.c
    ../../../Drivers/CMSIS_6/CMSIS/RTOS2/Source/: os_systick.c
  group Drivers/CMSIS-View
    ../../../Drivers/CMSIS-View/EventRecorder/Source/: EventRecorder.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dfsdm.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dsi.c stm32f4xx_hal_eth.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_fmpsmbus.c stm32f4xx_hal_fmpsmbus_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_lptim.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_mmc.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_smbus.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_adc.c stm32f4xx_ll_crc.c stm32f4xx_ll_dac.c stm32f4xx_ll_dma.c stm32f4xx_ll_dma2d.c stm32f4xx_ll_exti.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fmpi2c.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_gpio.c stm32f4xx_ll_i2c.c stm32f4xx_ll_lptim.c stm32f4xx_ll_pwr.c stm32f4xx_ll_rcc.c stm32f4xx_ll_rng.c stm32f4xx_ll_rtc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_spi.c stm32f4xx_ll_tim.c stm32f4xx_ll_usart.c stm32f4xx_ll_usb.c stm32f4xx_ll_utils.c
  group User/Core
    ../../Core/Device/STM32F405ZGTx/arm/: startup_stm32f405xx.s
    ../../Core/Device/STM32F405ZGTx/: stm32f4xx_hal_timebase_tim.c stm32f4xx_it.c system_stm32f4xx.c
    ../../Core/: main.c RTE_Components.h
    ../../Core/CMSIS-RTX/: RTX_Config.h
    ../../Core/CMSIS-View/: EventRecorderConf.h
target Release (6210000::V6.21::ARMCLANG)
  device: STM32F405ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: as above
  output: Release +hex
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=9 wLevel=3
  c define: STM32F405xx
  c include: ..\..\App;..\..\Core;..\..\Core\CMSIS-RTX;..\..\Core\CMSIS-View;..\..\Core\Device\STM32F429ZITx;..\..\..\Drivers\BSP;..\..\..\Drivers\CMSIS_6\CMSIS\Core\Include;..\..\..\Drivers\CMSIS_6\CMSIS\RTOS2\Include;..\..\..\Drivers\CMSIS-DSP\Include;..\..\..\Drivers\CMSIS-DSP\PrivateInclude;..\..\..\Drivers\CMSIS-RTX\Include;..\..\..\Drivers\CMSIS-Device\ST\STM32F4xx\Include;..\..\..\Drivers\CMSIS-View\EventRecorder\Include;..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\Utilities
  asm include: as above
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\..\Core\Device\STM32F405ZGTx\stm32f405xx.sct
